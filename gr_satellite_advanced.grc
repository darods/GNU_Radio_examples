options:
  parameters:
    author: Daniel-arod
    copyright: MIT
    description: Original example made by Daniel Estevez:https://youtu.be/TceMth67r9c
    generate_options: qt_gui
    id: gr_satellites_advanced
    output_language: python
    title: gr_satellites_advanced
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1800000'
  states: {}
- name: taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 20e3
    gain: '1.0'
    samp_rate: samp_rate
    width: 2e3
    win: firdes.WIN_HAMMING
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '5'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/daniel-arod/Documentos/Semillero/SDR/BeliefSat-master/Recordings/SDRSharp_20200704_132444Z_435912500Hz_IQ.wav
    nchan: '2'
    repeat: 'False'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-413e3+4'
    decim: '40'
    samp_rate: samp_rate
    taps: taps
    type: ccf
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 2e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate/40
    type: fir_filter_ccf
    width: '200'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '3000'
    srate: 48e3
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    marker1: '0'
    size: '3000'
    srate: '1200'
    style1: '0'
    type: float
    ymax: '3'
    ymin: '-3'
  states: {}
- name: satellites_ccsds_rs_deframer_0
  id: satellites_ccsds_rs_deframer
  parameters:
    frame_size: '58'
    precoding: None
    rs_basis: '"conventional"'
    rs_interleaving: '1'
    scrambler: '"none"'
    threshold: '0'
  states: {}
- name: satellites_fsk_demodulator_0
  id: satellites_fsk_demodulator
  parameters:
    baudrate: '1200'
    samp_rate: '45000'
    subaudio: 'False'
  states: {}
- name: satellites_hexdump_sink_0
  id: satellites_hexdump_sink
  parameters: {}
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0, '0']
- [analog_quadrature_demod_cf_0, '0', satellites_fsk_demodulator_0, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [freq_xlating_fir_filter_xxx_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [satellites_ccsds_rs_deframer_0, out, satellites_hexdump_sink_0, in]
- [satellites_fsk_demodulator_0, '0', qtgui_time_sink_x_1, '0']
- [satellites_fsk_demodulator_0, '0', satellites_ccsds_rs_deframer_0, '0']

metadata:
  file_format: 1
