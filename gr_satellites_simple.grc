options:
  parameters:
    author: Daniel-arod
    copyright: MIT
    description: Original example made by Daniel Estevez:https://youtu.be/TceMth67r9c
    generate_options: qt_gui
    id: tutorial_gr_satellites
    output_language: python
    title: gr_satellites_simple
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/daniel-arod/Documentos/Semillero/SDR/2021-05-11_charla_sdr_flisol_ec/aausat_4.wav
    repeat: 'True'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '3000'
    srate: samp_rate
    type: float
  states: {}
- name: satellites_hexdump_sink_0
  id: satellites_hexdump_sink
  parameters: {}
  states: {}
- name: satellites_satellite_decoder_0
  id: satellites_satellite_decoder
  parameters:
    definition: name
    name: AAUSAT-4
    norad: '39444'
    samp_rate: samp_rate
  states: {}

connections:
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0, '0', satellites_satellite_decoder_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle_0, '0']
- [satellites_satellite_decoder_0, out, satellites_hexdump_sink_0, in]

metadata:
  file_format: 1
