options:
  parameters:
    author: daniel-arod
    generate_options: qt_gui
    id: ejemplo_sintonizacion_dos_emisoras
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Ireq
  id: variable
  parameters:
    value: '94250000'
  states: {}
- name: mute0
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: 2,0
    label: mute izq
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: mute1
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: 2,2
    label: mute der
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: mute2
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: 2,1
    label: mute cent
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: samp_max_audio
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1180000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-400000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '506000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '2'
    quad_rate: '96000'
  states: {state: disabled}
- name: analog_wfm_rcv_1
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '2'
    quad_rate: '96000'
  states: {state: disabled}
- name: analog_wfm_rcv_2
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '2'
    quad_rate: '96000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: audio_sink_1
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {state: disabled}
- name: audio_sink_2
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: mute1
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: mute0
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: mute2
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 1,3
    name: '"tres frecuencias"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: samp_max_audio
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 1,2
    name: '"Radio derecha"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_freq_sink_x_2
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.2'
    bw: samp_max_audio
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,0
    name: '"Radio izq"'
    type: float
    wintype: firdes.WIN_RECTANGULAR
  states: {state: disabled}
- name: qtgui_freq_sink_x_3
  id: qtgui_freq_sink_x
  parameters:
    bw: '200000'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 1,1
    name: '"Radio central"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '97654000'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 0,0,1,4
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '10'
    interp: '1'
    taps: ''
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '10'
    interp: '1'
    taps: ''
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_2
  id: rational_resampler_xxx
  parameters:
    decim: '10'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: '97900000'
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_1, '1']
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_1, '0']
- [analog_wfm_rcv_0, '0', qtgui_freq_sink_x_2, '0']
- [analog_wfm_rcv_1, '0', blocks_multiply_const_vxx_0, '0']
- [analog_wfm_rcv_1, '0', qtgui_freq_sink_x_1, '0']
- [analog_wfm_rcv_2, '0', blocks_multiply_const_vxx_2, '0']
- [analog_wfm_rcv_2, '0', qtgui_freq_sink_x_3, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_1, '0']
- [blocks_multiply_const_vxx_1, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_2, '0', audio_sink_2, '0']
- [blocks_multiply_xx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_xx_1, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_1, '0', analog_wfm_rcv_1, '0']
- [rational_resampler_xxx_2, '0', analog_wfm_rcv_2, '0']
- [rtlsdr_source_0, '0', blocks_multiply_xx_0, '0']
- [rtlsdr_source_0, '0', blocks_multiply_xx_1, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rtlsdr_source_0, '0', rational_resampler_xxx_2, '0']

metadata:
  file_format: 1
